# Keil uVision project test.uvprojx, settings and files
target Target 1 (6210000::V6.21::..\..\Program Files\ArmCompilerforEmbedded6.21)
  device: LPC4357:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.10.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.4.0-fusa, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:I/O:STDOUT 1.2.0, Board Support:LED 1.0.0, Device:GPIO 1.1.0, Device:SCU 1.2.0, Device:Startup 1.0.0
